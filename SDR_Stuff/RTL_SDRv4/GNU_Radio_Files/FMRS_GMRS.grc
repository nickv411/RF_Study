options:
  parameters:
    author: nick
    generate_options: qt_gui
    id: FMRS_GMRS
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 89.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e5
  states: {}
- name: variable_freq
  id: variable_qtgui_range
  parameters:
    start: 460e6
    step: 0.025e6
    stop: 475e6
    value: 462.300e6
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '240000'
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '1'
    threshold: '-50'
    type: float
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: walkie.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-25e3'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 12000, 4000, window.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '25'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 12e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: variable_freq
    gain0: '15'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    type: float
    ymax: '-50'
    ymin: '-110'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: variable_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_nbfm_rx_0, '0', high_pass_filter_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_wavfile_sink_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_nbfm_rx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [high_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
