options:
  parameters:
    author: nick
    generate_options: qt_gui
    id: FMRS_GMRS
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 89.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e5
  states: {}
- name: variable_freq
  id: variable_qtgui_range
  parameters:
    start: 460e6
    step: '0.0125'
    stop: 475e6
    value: 461.919e6
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '240000'
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: walkie.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-81e3'
    decim: '5'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 12e3, 4e3)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 12e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: variable_freq
    gain0: '35'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: variable_freq
    fftsize: '1024'
    type: complex
    ymax: '-50'
    ymin: '-110'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: variable_freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_wavfile_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
