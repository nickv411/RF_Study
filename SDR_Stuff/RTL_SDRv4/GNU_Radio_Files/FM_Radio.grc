options:
  parameters:
    author: nick
    generate_options: qt_gui
    id: FMRS_GMRS
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 89.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e5
  states: {}
- name: variable_freq
  id: variable_qtgui_range
  parameters:
    start: 85e6
    step: 0.1e6
    stop: 110e6
    value: 89.1e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: '240000'
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: WBFM.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: variable_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: variable_freq
    fftsize: '1024'
    type: float
    ymax: '-50'
    ymin: '-110'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: variable_freq
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
